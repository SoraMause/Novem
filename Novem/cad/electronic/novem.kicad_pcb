# Repository SoraMause/Novem

## KiCad design Novem/cad/electronic/novem.kicad_pcb

Schematic: novem.sch

Parts:
BZ1: Bz; CSS-0575A-SMT
C1: 470u; CP_Elec_8x10.5
C2, C6, C11, C17: 10u; C_0603_HandSoldering_silk
C3, C8: 22u; C_0603_HandSoldering_silk
C4, C10, C12, C13, C14, C16, C18, C20, C21, C23, C24: 0.1u; C_0603_HandSoldering_silk
C5: 330u; CP_Elec_8x10.5
C7: 47u; C_1206_HandSoldering
C9: 0.01u; C_0603_HandSoldering_silk
C15: 1u; C_0603_HandSoldering_silk
C19: 4.7u; C_0603_HandSoldering_silk
C22, C25: 2.2u; C_0603_HandSoldering_silk
CN1: CONNECT; Pin_Header_Straight_1x02_Pitch2.54mm
D1, D2, D4, D5: LED_ALT; IRED_D5.0mm_angled
D3, D7, D8: LED; LED_0603_HandSoldering_silk
D6: D; D_0603
D9: LATBT66B
J1: Conn_01x02_Female; Pin_Header_Straight_2x01_Pitch2.54mm
Q1: IRLML6402; SOT-23_Handsoldering
Q2, Q3, Q8, Q9: 2N7002; SOT-23_Handsoldering
Q4, Q5, Q6, Q7: Q_Photo_NPN; ST-1KL3A
R1, R6: 330; R_0603_HandSoldering_silk
R2, R3, R7, R14, R17, R23, R25: 10k; R_0603_HandSoldering_silk
R4, R8: R; R_0805_HandSoldering_silk
R5, R9: 2.2k; R_0603_HandSoldering_silk
R10, R11, R12, R15, R16, R18, R19, R20, R21, R22: 1k; R_0603_HandSoldering_silk
R13: 510; R_0603_HandSoldering_silk
R24: 56k; R_0603_HandSoldering_silk
SW1: SW_SPST; PCM12SMTR
SW2: SW_Push; SKRPACE010
SW3: RESET; SKRPACE010
U1, U2: 1717_ie2_1024; Pin_Header_Straight_2x03_Pitch2.54mm
U3: AZ1117-5.0; SOT-223
U4: AZ1086H-3.3; SOT-223
U5: MPU-6500; QFN-24_3x3mm_Pitch0.4mm_silk
U6, U10: TB6614FNG; SSOP-16_4.4x5.2mm_Pitch0.65mm
U7: CSTCE12M0G52A; CSTCE12M0G52A-R0
U8: conn_02*03; SBH51LPSED03STBK
U9: STM32F405RGT; LQFP-64_10x10mm_Pitch0.5mm

Connections:
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.2, C14.2, C15.2, C16.2, C17.1, C18.1, C19.2, C20.2, C21.2, C22.2, C23.2, C24.1, C25.1, CN1.2, Q2.2 (S), Q3.2 (S), Q8.2 (S), Q9.2 (S), R3.2, R5.2, R7.2, R10.2, R11.2, R12.2, R14.1, R15.2, R16.2, R23.2, R24.2, R25.2, SW1.2, SW2.2, SW3.1, U1.3, U2.3, U3.1 (GND), U4.1, U5.11, U5.18, U5.20, U6.1, U6.5, U6.12, U7.2, U8.4, U9.12, U9.18, U9.63, U10.1, U10.5, U10.12
IN1_L: U6.2, U9.36
IN1_R: U9.40, U10.2
IN2_L: U6.3, U9.35
IN2_R: U9.39, U10.3
MOTOR_L1: U1.1, U6.6, U6.7
MOTOR_L2: U1.2, U6.10, U6.11
MOTOR_R1: U2.1, U10.6, U10.7
MOTOR_R2: U2.2, U10.10, U10.11
unnamed: BZ1.2, D6.2, Q8.3 (D)
unnamed: C13.1, U5.10
unnamed: C14.1, SW3.2, U9.7
unnamed: C22.1, U9.31
unnamed: C25.2, U9.47
unnamed: CN1.1, Q1.2 (S), R2.2
unnamed: D1.1, D2.2
unnamed: D2.1, R4.1
unnamed: D3.1, R5.1
unnamed: D4.1, D5.2
unnamed: D5.1, R8.1
unnamed: D7.1, R20.2
unnamed: D8.1, R21.2
unnamed: D9.1, R18.1
unnamed: D9.3, R22.1
unnamed: D9.4, R19.1
unnamed: J1.2, Q9.3 (D)
unnamed: Q1.1 (G), R2.1, SW1.1
unnamed: Q2.1 (G), R1.1, R3.1
unnamed: Q2.3 (D), R4.2
unnamed: Q3.1 (G), R6.1, R7.1
unnamed: Q3.3 (D), R8.2
unnamed: Q8.1 (G), R13.1, R14.2
unnamed: R24.1, U9.28
unnamed: U7.1, U9.5
unnamed: U7.3, U9.6
PWM_L: U6.14, U9.22
PWM_R: U9.23, U10.14
SCL: U5.23, U9.51
SD0: U5.9, U9.52
SDI: U5.24, U9.53
STBY: U6.15, U9.3, U10.15
VBAT: C1.1, C2.1, C11.2, C17.2, D3.2, J1.1, Q1.3 (D), R9.1, U3.3 (VI), U6.8, U6.9, U10.8, U10.9
VCC: C3.1, C5.1, C6.1, D1.2, D4.2, U1.4, U2.4, U3.2 (VO), U3.4, U4.3
VDD: BZ1.1, C7.1, C8.1, C9.1, C10.1, C12.2, C15.1, C16.1, C18.2, C19.1, C20.1, C21.1, C23.1, C24.2, D6.1, D7.2, D8.2, D9.2, Q4.1, Q5.1, Q6.1, Q7.1, R17.2, U4.2, U4.4, U5.8, U5.13, U6.16, U8.1, U9.1, U9.13, U9.19, U9.32, U9.48, U9.64, U10.16
batt_analog: C4.2, R9.2, R10.1, U9.20
boot: R23.1, U8.6, U9.60
buzzer_pwm: R13.2, U9.21
enc_LA: U1.5, U9.38
enc_LB: U1.6, U9.37
enc_RA: U2.5, U9.42
enc_RB: U2.6, U9.41
fledblue: R22.2, U9.17
fledgreen: R19.2, U9.62
fledred: R18.2, U9.61
fun: Q9.1 (G), R25.1, U9.55
gyro_cs: U5.22, U9.59
led1: R20.1, U9.57
led2: R21.1, U9.56
push1: R17.1, SW2.1, U9.26
sensor0: Q4.2, R11.1, U9.8
sensor1: Q6.2, R15.1, U9.9
sensor2: Q5.2, R12.1, U9.10
sensor3: Q7.2, R16.1, U9.11
sensor_paluseL: R1.2, U9.14
sensor_paluseR: R6.2, U9.2
usart3_rx: U8.2, U9.30
usart3_tx: U8.3, U9.29

Notes on the sheet:
Use VCC Power
MOTOR,ENCODER
IRLED SFH4550
USE VDD LINE
BUZZER
LED,PUSHSW
WALL SENSOR ST-1KL3A
MCU
POWER
GYRO MPU-6500
MOTOR DRIVER

Board: 2 copper layers, 69.0 x 100.0 mm, 84 parts (0 on the bottom side), 67 nets.

## Code that names these connections

File Novem/cad/electronic/novem.ioc (part):

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Mcu.Name=STM32F405RGTx
Mcu.Package=LQFP64
Mcu.UserName=STM32F405RGTx
PA0-WKUP.GPIOParameters=GPIO_Label
PA0-WKUP.GPIO_Label=sensor_paluseL
PA0-WKUP.Signal=GPIO_Output
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=fled_red
PA3.Signal=GPIO_Output
PA4.Signal=ADCx_IN4
PA5.Signal=S_TIM2_CH1_ETR
PA6.Signal=S_TIM3_CH1
PA7.Signal=S_TIM3_CH2
PA8.Signal=S_TIM1_CH1
PA9.Signal=S_TIM1_CH2
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=pushsw
PB0.Signal=GPIO_Input
PB10.Mode=Asynchronous
PB10.Signal=USART3_TX
PB11.Mode=Asynchronous
PB11.Signal=USART3_RX
PB14.GPIOParameters=GPIO_Label
PB14.GPIO_Label=IN2_L
PB14.Signal=GPIO_Output
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=IN1_L
PB15.Signal=GPIO_Output
PB3.Signal=S_TIM2_CH2
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=led2
PB4.Signal=GPIO_Output
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=led1
PB5.Signal=GPIO_Output
PB7.GPIOParameters=GPIO_Label
PB7.GPIO_Label=gyro_cs
PB7.Signal=GPIO_Output
PB8.GPIOParameters=GPIO_Label
PB8.GPIO_Label=fledred
PB8.Signal=GPIO_Output
PB9.GPIOParameters=GPIO_Label
PB9.GPIO_Label=fledgreen
PB9.Signal=GPIO_Output
PC0.Signal=ADCx_IN10
PC1.Signal=ADCx_IN11
PC10.Mode=Full_Duplex_Master
PC10.Signal=SPI3_SCK
PC11.Mode=Full_Duplex_Master
PC11.Signal=SPI3_MISO
PC12.Mode=Full_Duplex_Master
PC12.Signal=SPI3_MOSI
PC13-ANTI_TAMP.GPIOParameters=GPIO_Label
PC13-ANTI_TAMP.GPIO_Label=sensor_paluseR
PC13-ANTI_TAMP.Signal=GPIO_Output
PC14-OSC32_IN.GPIOParameters=GPIO_Label
PC14-OSC32_IN.GPIO_Label=stby
PC14-OSC32_IN.Signal=GPIO_Output
PC2.Signal=ADCx_IN12
PC3.Signal=ADCx_IN13
PC6.Signal=S_TIM8_CH1
PC7.Signal=S_TIM8_CH2
PC8.GPIOParameters=GPIO_Label
PC8.GPIO_Label=IN2_R
PC8.Signal=GPIO_Output
PC9.GPIOParameters=GPIO_Label
PC9.GPIO_Label=IN1_R
PC9.Signal=GPIO_Output
PH0-OSC_IN.Mode=HSE-External-Oscillator
PH0-OSC_IN.Signal=RCC_OSC_IN
PH1-OSC_OUT.Mode=HSE-External-Oscillator
PH1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=20000000
RCC.SYSCLKFreq_VALUE=160000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=novem

## Commit log

2018-12-19 set up pid param
2018-12-31 一応走るようになった。これ以前のプログラムに致命的なバグあり
2018-12-31 探索はそれなりに安定,最短走行可能
2018-12-31 斜めのスラロームパラメータを調整しないと走らない。
2019-01-07 最短走行調整中
2019-01-13 motion data update
2019-01-23 check battery voltage
2019-01-26 最短調整中(壁ありなら完走安定してきた)
2019-01-29 調整モード
2019-02-02 最短の壁切れ補正入れた
2019-02-08 吸引時の最短の安定性が上がった
2019-02-16 最短走行一応走る
2019-02-23 ハードウェアのメンテナンスをした
